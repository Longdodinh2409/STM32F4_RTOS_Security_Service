# Keil uVision project Security_service_STM32.uvprojx, settings and files
target Security_service_STM32 (5060750::V5.06 update 6 (build 750)::.\ARMCC)
  device: STM32F411VETx STMicroelectronics
  pack: Keil.STM32F4xx_DFP.3.1.1
  cpu: IRAM(0x20000000,0x00020000) IROM(0x08000000,0x00080000) CPUTYPE("Cortex-M4") FPU2 DSP CLOCK(12000000) ELITTLE
  output: Security_service_STM32 +hex
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=3 v6LangP=3 wLevel=2
  c define: USE_HAL_DRIVER,STM32F411xE
  c include: ../Core/Inc;../Drivers/STM32F4xx_HAL_Driver/Inc;../Drivers/STM32F4xx_HAL_Driver/Inc/Legacy;../Drivers/CMSIS/Device/ST/STM32F4xx/Include;../Drivers/CMSIS/Include;../3rdParty/FreeRTOS/include;../Core/Inc/Task_FingerPrint;../3rdParty/FreeRTOS/portable/RVDS/ARM_CM4F;../3rdParty/SEGGER/Config;../3rdParty/SEGGER/OS;../3rdParty/SEGGER/SEGGER;../3rdParty/SEGGER/SEGGER/Syscalls
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x20000
  group Application/MDK-ARM
    ./: startup_stm32f411xe.s
  group Application/User/Core
    ../Core/Src/: main.c stm32f4xx_it.c stm32f4xx_hal_msp.c stm32f4xx_hal_timebase_tim.c
  group Drivers/STM32F4xx_HAL_Driver
    ../Drivers/STM32F4xx_HAL_Driver/Src/: stm32f4xx_hal_tim.c stm32f4xx_hal_tim_ex.c stm32f4xx_hal_i2c.c stm32f4xx_hal_i2c_ex.c stm32f4xx_hal_rcc.c stm32f4xx_hal_rcc_ex.c stm32f4xx_hal_flash.c stm32f4xx_hal_flash_ex.c stm32f4xx_hal_flash_ramfunc.c stm32f4xx_hal_gpio.c stm32f4xx_hal_dma_ex.c stm32f4xx_hal_dma.c stm32f4xx_hal_pwr.c stm32f4xx_hal_pwr_ex.c stm32f4xx_hal_cortex.c stm32f4xx_hal.c stm32f4xx_hal_exti.c stm32f4xx_hal_uart.c
  group Drivers/CMSIS
    ../Core/Src/: system_stm32f4xx.c
  group FreeRTOS_kernel
    ../3rdParty/FreeRTOS/: croutine.c event_groups.c list.c queue.c stream_buffer.c tasks.c timers.c
    ../3rdParty/FreeRTOS/portable/MemMang/: heap_4.c
    ../3rdParty/FreeRTOS/portable/RVDS/ARM_CM4F/: port.c
  group Task_FingerPrint
    ../Core/Src/Task_FingerPrint/: task_uart_FingerPrint.c
  group Task_ParsingData
    ../Core/Src/Task_ParsingData/: task_ParsingData.c
  group Task_Display
    ../Core/Src/Task_Display/: fonts.c gui.c ssd1306.c
  group Task_UserButton
    ../Core/Src/Task_UserButton/: task_userbutton.c
  group Comm_BBB
    ../Core/Src/Comm_BBB/: Comm_BBB.c
  group SEGGER_RECORD
    ../3rdParty/SEGGER/Config/: SEGGER_SYSVIEW_Config_FreeRTOS.c
    ../3rdParty/SEGGER/OS/: SEGGER_SYSVIEW_FreeRTOS.c
    ../3rdParty/SEGGER/SEGGER/: SEGGER_RTT.c SEGGER_RTT_printf.c SEGGER_SYSVIEW.c
    ../3rdParty/SEGGER/SEGGER/Syscalls/: SEGGER_RTT_Syscalls_KEIL.c
software components: CMSIS:CORE 5.4.0
